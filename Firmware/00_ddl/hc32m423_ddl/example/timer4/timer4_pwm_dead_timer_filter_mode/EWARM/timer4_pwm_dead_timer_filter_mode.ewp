# IAR project timer4_pwm_dead_timer_filter_mode.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32M423; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ev_hc32m423_lqfp64; ..\..\..\..\bsp\components\w25qxx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: timer4_pwm_dead_timer_filter_mode.srec
  ILINK.IlinkOutputFile: timer4_pwm_dead_timer_filter_mode.out
  ILINK.IlinkIcfFile: hc32m423.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32M423; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ev_hc32m423_lqfp64; ..\..\..\..\bsp\components\w25qxx; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32m423.c
    ./: startup_hc32m423.s
  group driver
    ../../../../driver/src/: hc32m423_utility.c hc32m423_clk.c hc32m423_tmr4.c hc32m423_icg.c hc32m423_interrupts.c hc32m423_gpio.c
  group bsp/ev_hc32m423_lqfp64
    ../../../../bsp/ev_hc32m423_lqfp64/: ev_hc32m423_lqfp64.c ev_hc32m423_lqfp64_w25qxx.c
  group bsp/w25qxx
    ../../../../bsp/components/w25qxx/: w25qxx.c
  group source
    ../source/: main.c
