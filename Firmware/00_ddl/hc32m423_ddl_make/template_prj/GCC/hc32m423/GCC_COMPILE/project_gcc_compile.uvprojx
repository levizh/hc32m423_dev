# Keil uVision project project_gcc_compile.uvprojx, settings and files
target project_gcc_compile (5060020::V5.06 (build 20)::ARMCC)
  device: HC32M120J6TB HDSC
  pack: HDSC.HC32M120.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project_gcc_compile +hex
  group common
    ../: startup_hc32m120.S
    ./: system_hc32m120.c
software components: CMSIS:CORE 5.2.0
